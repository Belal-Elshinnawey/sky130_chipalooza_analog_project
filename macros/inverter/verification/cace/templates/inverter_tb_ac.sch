** sch_path: macros/inverter/verification/cace/templates/inverter_tb_ac.sch
**.subckt inverter_tb_ac
VDD VDD GND CACE{vdd}
C2 vout GND CACE{cload} m=1
VSS VSS GND 0
x1 VDD vin vout GND inverter
vin vin GND dc CACE{vcm} ac 1
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15 SEED=CACE[CACE{seed=12345}
+ + CACE{iterations=0}]
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.control

* optran 0 0 0 1u 1m 0

* save v(vin) v(vout)
save all

set num_threads=16

* AC Analysis
ac dec 101 1 1G

* Open-loop gain
let Aol=v(vout)/v(vin)
let Aol_dB = vdb(Aol)

* Measurements
* 10Hz closed-loop gain
meas ac Adc_ol_dB find Aol_dB when frequency = 10

* Upper 3dB cut-off frequency
let Amag_fc = Adc_ol_dB-3
meas ac fcu find frequency when Aol_dB = Amag_fc FALL=1

echo $&Adc_ol_dB $&fcu > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner_mos}
.param MC_PR_SWITCH=CACE{stat_global}
.param MC_MM_SWITCH=CACE{stat_mismatch}

**** end user architecture code
**.ends

* expanding   symbol:  inverter.sym # of pins=4
** sym_path: macros/inverter/schematic/xschem/inverter.sym
** sch_path: macros/inverter/schematic/xschem/inverter.sch
.subckt inverter VDD vin vout VSS
*.iopin VDD
*.iopin VSS
*.ipin vin
*.opin vout
XM1 vout vin VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=2.5 W='2 * 10 ' nf=10 ad='int((10 + 1)/2) * 2 / 10
+ * 0.29' as='int((10 + 2)/2) * 2 / 10 * 0.29' pd='2*int((10 + 1)/2) * (2 / 10 + 0.29)' ps='2*int((10 +
+ 2)/2) * (2 / 10 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout vin VSS VSS sky130_fd_pr__nfet_g5v0d10v5 L=2.5 W='2 * 10 ' nf=10 ad='int((10 + 1)/2) * 2 / 10
+ * 0.29' as='int((10 + 2)/2) * 2 / 10 * 0.29' pd='2*int((10 + 1)/2) * (2 / 10 + 0.29)' ps='2*int((10 +
+ 2)/2) * (2 / 10 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.GLOBAL GND
.GLOBAL VDD
.end
