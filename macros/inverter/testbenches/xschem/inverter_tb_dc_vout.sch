** sch_path: macros/inverter/testbenches/xschem/inverter_tb_dc_vout.sch
**.subckt inverter_tb_dc_vout
VDD VDD GND {VDD}
C1 vout GND {Cload} m=1
Vgsp vin GND 0
x1 VDD vin vout GND inverter
**** begin user architecture code


.include ../../../netlist/pex/inverter_magic_pex_3.spice
.param VDD=3.3
.csparam VDD=VDD
.param Vcm=1.2
.csparam Vcm=Vcm
.temp 27
.param Cload=10p
.param Rload=1k
.options savecurrents klu method=gear reltol=1e-3 abstol=1e-15 gmin=1e-15
.control

save all

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* DC Sweep
dc Vgsp 0 $&VDD 1m
remzerovec
write @schname\.raw
set appendwrite

* Plotting
plot vin vout

* Measurement
meas dc Vgsp_at_Vcm when vout=Vcm
print Vgsp_at_Vcm

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/@schname\.txt v(vin) v(vout)

*quit
.endc



.lib $::SKYWATER_MODELS/sky130.lib.spice tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends

* expanding   symbol:  inverter.sym # of pins=4
** sym_path: macros/inverter/schematic/xschem/inverter.sym
** sch_path: macros/inverter/schematic/xschem/inverter.sch
.subckt inverter VDD vin vout VSS
*.iopin VDD
*.iopin VSS
*.ipin vin
*.opin vout
XM1 vout vin VDD VDD sky130_fd_pr__pfet_g5v0d10v5 L=2.5 W='2 * 10 ' nf=10 ad='int((10 + 1)/2) * 2 / 10 * 0.29'
+ as='int((10 + 2)/2) * 2 / 10 * 0.29' pd='2*int((10 + 1)/2) * (2 / 10 + 0.29)' ps='2*int((10 + 2)/2) * (2 / 10 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XM2 vout vin VSS VSS sky130_fd_pr__nfet_g5v0d10v5 L=2.5 W='2 * 10 ' nf=10 ad='int((10 + 1)/2) * 2 / 10 * 0.29'
+ as='int((10 + 2)/2) * 2 / 10 * 0.29' pd='2*int((10 + 1)/2) * (2 / 10 + 0.29)' ps='2*int((10 + 2)/2) * (2 / 10 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.GLOBAL GND
.GLOBAL VDD
.end
